# IAR project demo-coap.ewp, settings and files
configuration CC120x_SRV (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xlfn.h
  General.OGChipSelectMenu: MSP430F5438A MSP430F5438A
  General.GStackSize2: 320
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: MAC_ADDR_WORD=0x1200; LOGGER_LEVEL=0; LOGGER_DEMO_COAP=1; DEMO_USE_COAP=1; USE_UDPALIVE_SERVICE=1; DEMO_USE_UDP_SOCKET=1; DEMO_UDP_SOCKET_ROLE_CLIENT=1; CONF_USE_SERVER=1; NET_USE_RPL=1; IAR_COMPILER
  ICC430.CCDiagSuppress: Pa050, Pe161
  ICC430.newCCIncludePaths: ..\..\..\..\..\..\..\..\..\; ..\..\..\..\..\..\..\..\..\emb6\demo\coap\server; ..\..\..\..\..\..\..\..\..\emb6\demo\udp_alive; ..\..\..\..\..\..\..\..\..\emb6\demo\udp_socket; ..\..\..\..\..\..\..\..\..\emb6\target; ..\..\..\..\..\..\..\..\..\emb6\target\arch\msp430\msp430f5\ti\device\msp430f5xxx\inc; ..\..\..\..\..\..\..\..\..\emb6\target\bsp\ti_trxeb_cc120x; ..\..\..\..\..\..\..\..\..\emb6\target\if\cc120x; ..\..\..\..\..\..\..\..\..\emb6\target\mcu\msp430x5xx; ..\..\..\..\..\..\..\..\..\emb6\emb6; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\apl\er-coap; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\apl\rest-engine; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\net\ipv6; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\net\ipv6\multicast; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\net\rpl; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\net\sicslowpan; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\tport; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\dll\dllsec; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\dll\dllc; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\dll\mac; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\dll\framer; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\phy; ..\..\..\..\..\..\..\..\..\emb6\utils\inc
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5438A.xcl
  XLINK.XlinkStackSize: 1
configuration CC112x_SRV (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: MAC_ADDR_WORD=0x1120; LOGGER_LEVEL=0; LOGGER_DEMO_COAP=1; DEMO_USE_COAP=1; USE_UDPALIVE_SERVICE=1; DEMO_USE_UDP_SOCKET=1; DEMO_UDP_SOCKET_ROLE_CLIENT=1; CONF_USE_SERVER=1; NET_USE_RPL=1; IAR_COMPILER
  ICC430.newCCIncludePaths: ..\..\..\..\..\..\..\..\..\; ..\..\..\..\..\..\..\..\..\emb6\demo\coap\server; ..\..\..\..\..\..\..\..\..\emb6\demo\udp_alive; ..\..\..\..\..\..\..\..\..\emb6\demo\udp_socket; ..\..\..\..\..\..\..\..\..\emb6\target; ..\..\..\..\..\..\..\..\..\emb6\target\arch\msp430\msp430f5\ti\device\msp430f5xxx\inc; ..\..\..\..\..\..\..\..\..\emb6\target\bsp\ti_trxeb_cc112x; ..\..\..\..\..\..\..\..\..\emb6\target\if\cc112x; ..\..\..\..\..\..\..\..\..\emb6\target\mcu\msp430x5xx; ..\..\..\..\..\..\..\..\..\emb6\emb6; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\apl\er-coap; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\apl\rest-engine; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\net\ipv6; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\net\ipv6\multicast; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\net\rpl; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\net\sicslowpan; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\tport; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\dll\dllsec; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\dll\dllc; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\dll\mac; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\dll\framer; ..\..\..\..\..\..\..\..\..\emb6\emb6\inc\phy; ..\..\..\..\..\..\..\..\..\emb6\utils\inc
  group demo
    ../../../../../../../../demo/: demo_main.c
  group emb6/demo/coap/client
    ../../../../../../../../demo/coap/client/: demo_coap_cli.c
  group emb6/demo/coap/server
    ../../../../../../../../demo/coap/server/: demo_coap_srv.c
  group emb6/demo/coap/server/resources
    ../../../../../../../../demo/coap/server/resources/: res-led.c res-push.c res-radio.c res-temp.c
  group emb6/demo/udp_alive
    ../../../../../../../../demo/udp_alive/: demo_udp_alive.c
  group emb6/demo/udp_socket
    ../../../../../../../../demo/udp_socket/: demo_udp_socket.c
  group emb6/emb6
    ../../../../../../../../emb6/: emb6.c
  group emb6/emb6/src/apl/er-coap
    ../../../../../../../../emb6/src/apl/er-coap/: er-coap-block1.c er-coap-engine.c er-coap-observe.c er-coap-res-well-known-core.c er-coap-separate.c er-coap-transactions.c er-coap.c
  group emb6/emb6/src/apl/rest-engine
    ../../../../../../../../emb6/src/apl/rest-engine/: rest-engine.c
  group emb6/emb6/src/dll/dllc
    ../../../../../../../../emb6/src/dll/dllc/: dllc_802154.c dllc_null.c linkaddr.c
  group emb6/emb6/src/dll/dllsec
    ../../../../../../../../emb6/src/dll/dllsec/: dllsec_null.c
  group emb6/emb6/src/dll/framer
    ../../../../../../../../emb6/src/dll/framer/: framer_802154.c
  group emb6/emb6/src/dll/mac
    ../../../../../../../../emb6/src/dll/mac/: mac_802154.c mac_802154_ule.c mac_null.c smartmac_framer.c
  group emb6/emb6/src/net/ipv6
    ../../../../../../../../emb6/src/net/ipv6/: nbr-table.c tcpip.c uip-debug.c uip-ds6-nbr.c uip-ds6-route.c uip-ds6.c uip-icmp6.c uip-nameserver.c uip-nd6.c uip-packetqueue.c uip-split.c uip-udp-packet.c uip6.c uiplib.c
  group emb6/emb6/src/net/ipv6/multicast
    ../../../../../../../../emb6/src/net/ipv6/multicast/: roll-tm.c smrf.c uip-mcast6-route.c uip-mcast6-stats.c
  group emb6/emb6/src/net/rpl
    ../../../../../../../../emb6/src/net/rpl/: rpl-dag.c rpl-ext-header.c rpl-icmp6.c rpl-mrhof.c rpl-timers.c rpl.c
  group emb6/emb6/src/net/sicslowpan
    ../../../../../../../../emb6/src/net/sicslowpan/: framer-802154.c framer.c sicslowpan.c
  group emb6/emb6/src/phy
    ../../../../../../../../emb6/src/phy/: phy_802154.c phy_framer_802154.c phy_null.c
  group emb6/emb6/src/tport
    ../../../../../../../../emb6/src/tport/: tcp-socket.c udp-socket.c
  group emb6/target/arch/msp430/msp430x5/ti/device/msp430f5xxx/src
    ../../../device/msp430f5xxx/src/: infoflash.c int.c io.c key.c lcd.c lcd_dogm128_6_alphabet.c led.c low_level_init.c mcu.c rtc.c spi.c tmr.c uart.c
  group emb6/target/bsp
    ../../../../../../../bsp/: bsp.c
  group emb6/target/bsp/ti_trxeb_cc112x
    ../../../../../../../bsp/ti_trxeb_cc112x/: board_conf.c
  group emb6/target/bsp/ti_trxeb_cc120x
    ../../../../../../../bsp/ti_trxeb_cc120x/: board_conf.c
  group emb6/target/if/cc112x
    ../../../../../../../if/cc112x/: cc112x.c cc112x_spi.c
  group emb6/target/if/cc120x
    ../../../../../../../if/cc120x/: cc120x.c cc120x_spi.c
  group emb6/target/mcu/msp430f5438a
    ../../../../../../../mcu/msp430f5438a/: msp430x5xx.c
  group emb6/utils/src
    ../../../../../../../../utils/src/: ctimer.c etimer.c evproc.c lib_crc.c lib_tmr.c list.c memb.c mmem.c packetbuf.c queuebuf.c random.c ringbuffer.c stimer.c timer.c
